# checksum of the selfsh for this camera module
SRC_URI[tarball.sha256sum] = "e06f77e47c45ff8be0bc622866bc39675fb53a6f88569db0fe3be169b1bd97b9"

require basler-dart-bcon-mipi.inc

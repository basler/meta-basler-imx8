LICENSE = "Basler-SLA-02 & BSD-3-Clause & OpenSSL"
LIC_FILES_CHKSUM = "file://opt/dart-bcon-mipi/share/doc/${PN}/copyright;md5=ff8962a0d69b960bd5b0a2bd0c97c184"
# checksum of the selfsh for this camera module
SRC_URI[tarball.sha256sum] = "41f6eb7061feec9b25b7dcd5e08cfa7945284cfbb0b2c7d15a31c19bdb373781"

require basler-dart-bcon-mipi.inc

# checksum of the selfsh for this camera module
SRC_URI[tarball.sha256sum] = "252ee0959db4b40092dc9dd5d90e74d490113a700927de4d924aa95e115b237f"

require basler-dart-bcon-mipi.inc
require basler-dart-bcon-mipi-vvcam-mixin.inc

# checksum of the selfsh for this camera module
SRC_URI[tarball.sha256sum] = "5a10071a36761e2f9dd3c2df4667adb517c25e5f3fc4ddf602ca6fa908c5ecba"

require basler-dart-bcon-mipi.inc
require basler-dart-bcon-mipi-vvcam-mixin.inc

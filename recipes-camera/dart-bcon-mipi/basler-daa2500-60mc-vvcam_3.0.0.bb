# checksum of the selfsh for this camera module
SRC_URI[tarball.sha256sum] = "98d9547ec8a7b7c5b3521f2c5319991d98bfcea3382ae145dc68dc07cc2f2f25"

require basler-dart-bcon-mipi.inc
require basler-dart-bcon-mipi-vvcam-mixin.inc

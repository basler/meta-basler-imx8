LICENSE = "Basler-SLA-02 & BSD-3-Clause & OpenSSL"
LIC_FILES_CHKSUM = "file://opt/dart-bcon-mipi/share/doc/${PN}/copyright;md5=ff8962a0d69b960bd5b0a2bd0c97c184"
# checksum of the selfsh for this camera module
SRC_URI[tarball.sha256sum] = "04468fce23ba68b5ed2d7c63ca328ac0049aaf362775b37aad2b8ccd73910c9b"

require basler-dart-bcon-mipi.inc

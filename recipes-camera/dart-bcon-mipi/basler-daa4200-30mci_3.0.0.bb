# checksum of the selfsh for this camera module
SRC_URI[tarball.sha256sum] = "8b266cd5b070c1c429afb41bdd304f5de875b4347e54781884f03a06beb910b5"

require basler-dart-bcon-mipi.inc

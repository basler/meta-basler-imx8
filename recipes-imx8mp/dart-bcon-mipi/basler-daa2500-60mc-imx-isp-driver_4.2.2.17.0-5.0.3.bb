DESCRIPTION = "Basler camera binary drivers"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://COPYING;md5=2383fee3f7f91dfa72b970b1bf0d8de4"

SRC_URI[sha256sum] = "8af61db6af8e829b9e48822b58b0391f0990dd8c1b2d28ebfef66dcabbcd1171"

require basler-dart-bcon-mipi-imx-isp.inc

DESCRIPTION = "Basler camera binary drivers"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://COPYING;md5=2383fee3f7f91dfa72b970b1bf0d8de4"

SRC_URI[sha256sum] = "315f7ba9596d8c56462083f73d16855e053684e7913f479861876d2a15485d4b"

require basler-dart-bcon-mipi-imx-isp.inc

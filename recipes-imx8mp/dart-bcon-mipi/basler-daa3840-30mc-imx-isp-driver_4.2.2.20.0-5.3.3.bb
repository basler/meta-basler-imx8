require basler-dart-bcon-mipi-imx-isp.inc

SRC_URI[sha256sum] = "0a6333ba4939c2e4b53dcfec4af2d404374cd5ff546f10cd9085ae685099b76c"

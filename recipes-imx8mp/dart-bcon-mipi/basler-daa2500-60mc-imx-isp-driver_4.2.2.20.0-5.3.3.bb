require basler-dart-bcon-mipi-imx-isp.inc

SRC_URI[sha256sum] = "05049f5bf6fdbaf816dd7c1577cdf4e29c943270e9a000e8ebbdddc8556b4cc9"
